# Keil uVision project CoreMark.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: CoreMark +hex
  group Source Group 1
    ./src/: main.c STC32G_Delay.c stc_usb_cdc_32g.lib STC32G_NVIC.c STC32G_Timer.c STC32G_Timer_Isr.c
  group CoreMark
    ./CoreMark/: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c
    ./CoreMark/simple/: core_portme.c ee_printf.c
